require petalinux-installer.inc
