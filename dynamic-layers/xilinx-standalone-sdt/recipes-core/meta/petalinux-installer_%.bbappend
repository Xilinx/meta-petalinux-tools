TOOLCHAIN_HOST_TASK += "\
	nativesdk-sdk-provides-dummy \
	nativesdk-lopper \
	nativesdk-xilinx-lops \
	nativesdk-esw-conf \
"
